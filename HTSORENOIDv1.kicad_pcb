# Repository hamuchan214/HTSORv1

## KiCad design HTSORENOIDv1.kicad_pcb

Parts:
C1: 1000u; CP_Radial_D10.0mm_P5.00mm
C2, C3, C4: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5, C7, C9, C12, C13: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C6: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C11: 4.7u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: D; SS2040FL
D2, D3, D4, D5: Blue; LED_0603_1608Metric
D6, D7, D8, D9, D10, D11, D12: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
IC1: TJA1441AT_0Z; SOIC127P600X175-8N; Mouser Part Number 771-TJA1441AT/0Z
J1, J2: Conn_01x04; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
J3, J6, J7, J8, J9, J10, J11, J12, J13, J14: Conn_01x02; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J15, J16: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J17, J18: Conn_01x01_Pin; ねじ端子(縦)
JP1: Jumper_2_Bridged; PinHeader_1x02_P2.54mm_Vertical
Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10: AO3400A; SOT-23
R1, R2, R4, R42: 10k; R_0603_1608Metric
R3: 1k; R_0603_1608Metric
R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R17, R18, R19, R20, R21, R22, R23, R24, R25, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39, R40, R41: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R43: 120; R_0603_1608Metric
SW1, SW2: SW_Push; TVAF06
U1: STM32F303K8Tx; LQFP-32_7x7mm_P0.8mm
U2: ADP3338AKCZ-3.3; SOT230P700X180-4N; MPN ADP3338AKCZ-3.3
U3: NJM78L12SU3; TO-252-2
U4, U5: TLP291-4; SOIC-16_4.55x10.3mm_P1.27mm

Connections:
+3.3V: C3.1, C9.1, C11.1, D1.2 (A), IC1.5 (VIO), J13.1, J14.1, J15.4, J16.4, R3.1, SW2.2, U1.1 (VDD), U1.5 (VDDA), U1.17 (VDD), U2.2 (OUT)
+8V: C6.1, C7.1, R4.2, U3.3 (VOUT), U4.10, U4.12, U4.14, U4.16, U5.10, U5.12, U5.14, U5.16
+24V: C1.1, C4.1, C5.1, J3.1, J6.1, J7.1, J8.1, J9.1, J10.1, J11.1, J12.1, J17.1, R1.2, U3.1 (VIN)
BOOT: R42.1, SW2.1, U1.31 (BOOT0)
CANH: IC1.7 (CANH), J1.4, J2.4, JP1.1 (A)
CANL: IC1.6 (CANL), J1.2, J2.2, R43.2
CAN_RX: IC1.4 (RXD), U1.21 (PA11)
CAN_TX: IC1.1 (TXD), U1.22 (PA12)
GND: C2.2, C3.2, C9.2, C11.2, C12.2, C13.2, D3.1 (K), D4.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), IC1.2 (GND), IC1.8 (S), J1.1, J2.1, J15.2, J16.2, R5.2, R6.2, R7.2, R8.2, R9.2, R10.2, R11.2, R12.2, R13.2, R14.2, R42.2, SW1.1, U1.16 (VSS), U1.32 (VSS), U2.1 (GND), U4.2, U4.4, U4.6, U4.8, U5.2, U5.4, U5.6, U5.8
GNDPWR: C1.2, C4.2, C5.2, C6.2, C7.2, D2.1 (K), D5.1 (K), J18.1, Q3.2 (S), Q4.2 (S), Q5.2 (S), Q6.2 (S), Q7.2 (S), Q8.2 (S), Q9.2 (S), Q10.2 (S), R17.1, R18.1, R19.1, R20.1, R21.1, R22.1, R23.1, R24.1, U3.2 (GND)
LED1: R35.1, U1.30 (PB7)
LED2: R36.1, U1.29 (PB6)
LED3: R37.1, U1.28 (PB5)
LED4: R38.1, U1.27 (PB4)
LED5: R39.1, U1.26 (PB3)
LED6: R40.1, U1.25 (PA15)
LED7: R41.1, U1.18 (PA8)
NRST: C12.1, SW1.2, U1.4 (NRST)
unnamed: D2.2 (A), R1.1
unnamed: D3.2 (A), R2.2
unnamed: D4.2 (A), R3.2
unnamed: D5.2 (A), R4.1
unnamed: D6.2 (A), R35.2
unnamed: D7.2 (A), R36.2
unnamed: D8.2 (A), R37.2
unnamed: D9.2 (A), R38.2
unnamed: D10.2 (A), R39.2
unnamed: D11.2 (A), R40.2
unnamed: D12.2 (A), R41.2
unnamed: JP1.2 (B), R43.1
unnamed: Q3.1 (G), R25.2
unnamed: Q4.1 (G), R28.2
unnamed: Q5.1 (G), R29.2
unnamed: Q6.1 (G), R30.2
unnamed: Q7.1 (G), R31.2
unnamed: Q8.1 (G), R32.2
unnamed: Q9.1 (G), R33.2
unnamed: Q10.1 (G), R34.2
unnamed: R17.2, R25.1, U4.9
unnamed: R18.2, R28.1, U4.11
unnamed: R19.2, R29.1, U4.13
unnamed: R20.2, R30.1, U4.15
unnamed: R21.2, R31.1, U5.9
unnamed: R22.2, R32.1, U5.11
unnamed: R23.2, R33.1, U5.13
unnamed: R24.2, R34.1, U5.15
O3: J7.2, Q3.3 (D)
O4: J9.2, Q4.3 (D)
O5: J11.2, Q5.3 (D)
O6: J3.2, Q6.3 (D)
O7: J6.2, Q7.3 (D)
O8: J8.2, Q8.3 (D)
O9: J10.2, Q9.3 (D)
O10: J12.2, Q10.3 (D)
SN3: R7.1, U1.6 (PA0), U4.7
SN4: R8.1, U1.7 (PA1), U4.5
SN5: R9.1, U1.8 (PA2), U4.3
SN6: R10.1, U1.9 (PA3), U4.1
SN7: R11.1, U1.10 (PA4), U5.7
SN8: R12.1, U1.11 (PA5), U5.5
SN9: R13.1, U1.12 (PA6), U5.3
SN10: R14.1, U1.13 (PA7), U5.1
SW1: J13.2, R6.1, U1.15 (PB1)
SW2: J14.2, R5.1, U1.14 (PB0)
SYS_SWCLK: J15.1, U1.24 (PA14)
SYS_SWDIO: J15.3, U1.23 (PA13)
USART1_RX: J16.3, U1.20 (PA10)
USART1_TX: J16.1, U1.19 (PA9)
VCC: C2.1, C13.1, D1.1 (K), IC1.3 (VCC), J1.3, J2.3, R2.1, U2.3 (IN)

Notes on the sheet:
BOOTSW
CANトランシーバー
RSTSW

Board: 2 copper layers, 90.0 x 55.0 mm, 99 parts (12 on the bottom side), 69 nets.

## Commit log

2023-09-07 update
    PCBの枠を追加、回路図の更新
